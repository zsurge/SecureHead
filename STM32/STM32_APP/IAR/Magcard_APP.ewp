# IAR project Magcard_APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082,Pa093
  ICCARM.CCIncludePath2: ..\core_cm3; ..\dev; ..\lib\inc; ..\user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Magcard_APP.hex
  ILINK.IlinkOutputFile: Magcard_APP.out
  ILINK.IlinkIcfFile: startup\Magcard_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group core
    ../core_cm3/: core_cm3.c system_stm32f10x.c system_stm32f10x.h
    startup/: startup_stm32f10x_md.s
  group dev
    ../dev/: dev_eprom.c dev_msread.c dev_timer.c dev_uart.c stm32f10x_it.c
  group lib
    ../lib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ../user/: aes.c app.c des.c dukpt.c main.c sha1.c utilities.c
    startup/: HSC32K1_Base.a
