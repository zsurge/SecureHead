# Keil uVision project EncryptMagcardApp.uvproj, settings and files
target EncryptMagcardApp (ARM-ADS)
  device: GD32F150G8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: EncryptMagcardApp +hex
  AfterMake: fromelf.exe --bin -o Objects\BinaryOutput\EncryptMagcardApp.bin Objects\EncryptMagcardApp.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\CMSIS\GD32F1x0\Include;..\GD32F1x0_Peripherals\Include;..\GD32F1x0_usbd_driver\Include;..\Inc;..\Dev
  library: MicroLIB
  memory RVCT4: ROM 0x8003400 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../Src/: aes.c app.c custom_hid_core.c des.c dukpt.c gd32f1x0_it.c ini.c main.c sha1.c systick.c usb_endp.c utilities.c magdecode.c Mylib.c
  group Dev
    ../Dev/: dev_eprom.c dev_msread.c dev_timer.c dev_uart.c
  group GD32F150 Peripherals
    ../GD32F1x0_Peripherals/Source/: gd32f1x0_dbg.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_rcu.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group GD32F150 Usb Lib
    ../GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group Startup
    ../Startup/: startup_gd32f1x0.s
  group CMSIS
    ../CMSIS/GD32F1x0/Source/: system_gd32f1x0.c
