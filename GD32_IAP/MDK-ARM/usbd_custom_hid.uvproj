# Keil uVision project usbd_custom_hid.uvproj, settings and files
target HID_custom (ARM-ADS)
  device: GD32F150G8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Custom_HID +hex
  AfterMake: fromelf.exe --bin -o GD32150R-OBJ\BinaryOutput\iap.bin GD32150R-OBJ\Custom_HID.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c misc: --c99
  c include: ..\inc;..\CMSIS\GD\GD32F1x0\Include;..\GD32F1x0_standard_peripheral\Include;..\GD32F1x0_usbd_driver\Include;..\dev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x33ff
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../src/: gd32f1x0_it.c custom_hid_core.c iap.c main.c ini.c systick.c usb_endp.c
  group CMSIS
    ../CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F150_Peripherals
    ../GD32F1x0_standard_peripheral/Source/: gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_usart.c gd32f1x0_exti.c gd32f1x0_fmc.c
  group Startup
    ../CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group USBD_Drivers
    ../GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group Doc
    ../: readme.txt
  group Dev
    ../dev/: dev_eprom.c dev_uart.c
